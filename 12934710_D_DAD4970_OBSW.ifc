Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 53175c47-f2ff-4f44-89e6-675d35e89209, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:01:38+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12934710_D_DAD4970_OBSW:28D4970B_D_12934710_DAD4970_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, z_Miele_Design_OBSW, Výchozí Nový materiál, <Unnamed>, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 936 mm; Depth: 171 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28D4970B_D_12934710_DAD4970_OBSW; sets with these values: 2

# IfcDistributionPort, Port_351299_1
Description: Flow; FlowDirection: SOURCEANDSINK
